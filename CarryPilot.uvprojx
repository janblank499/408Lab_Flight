# Keil uVision project CarryPilot.uvprojx, settings and files
target CarryPilot_LaunchPad_V6.0.2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIFLY_V3 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1 __USE_ANSI_EXAMPLE_RAND
  c include: .\Libraries\inc;.\Libraries\utils;.\WP_Ctrl;.\WP_Src;.\User;.\Libraries\utils;.\Libraries\driverlib;.\WP_Src\VL53L1X\core;.\WP_Src\VL53L1X
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group 芯片官方库Library
    ./Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group 主函数User
    ./User/: Headfile.h main.c startup_rvmdk.S
  group 硬件资源驱动CP_Src
    ./Libraries/utils/: uartstdio.c
    ./WP_Src/: Calibration.c CalibrationRoutines.c Bling.c Filter.c GPS.c IST8310.c Key.c ICM2068X.c myiic.c OLED.c OpticalFlow_LC306.c PPM.c RC.c Ringbuf.c Schedule.c SPL06.c Time.c Time_Cnt.c US_100.c SYSTEM.c Usart.c WP_ADC.c wp_flash.c WP_Math.c WP_PWM.c ssd1306.c Soft_I2C.c QMC5883.c tfmini.c tfmini.h NCLink.c TOFSensor.c Quaternion.c Compass.c Double.c Reserved_IO.c Reserved_Serialport.c LSN10.c speaker.c
  group 状态估计与基础飞行控制CP_Ctrl
    ./WP_Ctrl/: Earth_Declination.c Sensor.c SINS.c control_land.c PID.c control_althold.c control_poshold.c OpticalFlow_Control.c WP_Ctrl.c License.c NamelessCotrun_OpticalFlow.c NamelessCotrun_SDK.c Temperature_Ctrl.c ADC_Button.c
  group 用户应用开发控制API_Ctrl
    ./WP_Ctrl/: Developer_Mode.c Subtask_Demo.c
